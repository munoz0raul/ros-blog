PACKAGECONFIG_remove_intel-corei7-64 = "xcomposite-glx"
