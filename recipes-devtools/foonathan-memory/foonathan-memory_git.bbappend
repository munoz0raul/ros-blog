SRC_URI_remove = " git://github.com/foonathan/memory.git;protocol=https;name=main "

SRC_URI_append = " git://github.com/foonathan/memory.git;protocol=https;name=main;branch=main "


SRCREV_main = "e48965144d417469e712b3125398e6d00529c575"
